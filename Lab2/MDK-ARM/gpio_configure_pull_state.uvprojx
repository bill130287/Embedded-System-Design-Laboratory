# Keil uVision project gpio_configure_pull_state.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MT7687F MediaTek
  pack: MediaTek.MTx.4.6.1
  cpu: IROM(0x10000000,0x00200000) IRAM(0x20000000,0x00040000) IRAM2(0x00100000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gpio_configure_pull_state
  AfterMake: fromelf.exe --bin -o $L@L.bin #L
  AfterMake: fromelf.exe -c -o $L@L.dis #L
  c flags: Optim=4 OneElfS=1 wLevel=2
  c misc: --c99
  c include: ..\inc;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include;..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\driver\CMSIS\Device\MTK\mt7687\Include;..\..\..\..\..\driver\CMSIS\Include;..\..\..\..\..\kernel\service\inc;..\..\..\..\..\driver\chip\inc;..\..\..\..\..\driver\chip\mt7687\inc;..\..\..\..\..\driver\chip\mt7687\src\common\include;..\..\common\inc;..\..\..\..\..\middleware\third_party\lwip\ports\include;..\..\..\..\..\middleware\third_party\lwip\src\include\lwip;..\..\..\..\..\middleware\MTK\verno\inc
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x100000 size 0x10000
  scatter file: .\flash.sct
  link misc: --entry Reset_Handler --first __isr_vector
  group app
    ../src/: main.c
    ../../../../../driver/chip/mt7687/src/common/include/: hal_I2C.h hal_i2s_internal.h i2c.h low_hal_adc.h
  group driver
    ../../../../../driver/chip/mt7687/src/common/: top.c hal_gpio_7687.c dma.c hal_pinmux.c low_hal_gpio.c pinmux.c nvic.c uart.c timer.c gpt.c hal_I2C.c i2c.c
    ../../../../../driver/chip/mt7687/src/: hal_nvic_internal.c hal_nvic.c hal_gpio.c hal_log.c hal_uart.c hal_gpt.c hal_i2c_master.c hal_adc.c hal_spi_slave.c
  group cmsis
    ./: startup_mt7687.s
    ../src/: system_mt7687.c
